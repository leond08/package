## package/python-iptables/Config.in
```kconfig
config BR2_PACKAGE_PYTHON_IPTABLES
	bool "python-iptables"
	help
	  Python bindings for iptables.

	  https://github.com/ldx/python-iptables
```
